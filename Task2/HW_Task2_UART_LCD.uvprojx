# Keil uVision project HW_Task2_UART_LCD.uvprojx, settings and files
target Main_Group (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR1901VC1 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HW_Task2_UART_LCD
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\prj_files\src;.\prj_files\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Prj_files
    ./prj_files/src/: main.c
  group libs
    ./prj_files/src/: uLCD_func.c uUART_func.c uRST_CLK_init.c uTimer_init.c u_LED_func.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:TIMER 2.0.3, Drivers:UART 2.0.3
